# Keil uVision project Project.uvproj, settings and files
target HT32F1755_2755_DVB (ARM-ADS)
  device: HT32F1765 Holtek
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HT32F1755_2755_DVB +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F1755_2755_DVB
  c include: \;..\library\HT32F175x_275x_Driver\inc;..\library\CMSIS\Include;..\library\Device\Holtek\HT32F175x_275x\Include;..\utilities;..\user;..\system\sys;..\system\delay;..\system\usart;..\hardware\KEY;..\hardware\LED;..\hardware\TIMER;..\hardware\LCD;..\hardware\TOUCH;..\hardware\24CXX;..\hardware\IIC;..\hardware\24bitAD;..\hardware\Disp;..\hardware\TN9;..\hardware\RTC;..\hardware\FAN;..\hardware\BUZZER;..\hardware\EX
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group User
    ./: main.c ht32f175x_275x_it.c
  group RVMDK
    ../library/Device/Holtek/HT32F175x_275x/Source/ARM/: startup_ht32f175x_275x.s
  group Library
    ../library/HT32F175x_275x_Driver/src/: ht32f175x_275x_adc.c ht32f175x_275x_bftm.c ht32f175x_275x_ckcu.c ht32f175x_275x_cmp_op.c ht32f175x_275x_exti.c ht32f175x_275x_flash.c ht32f175x_275x_gpio.c ht32f175x_275x_gptm.c ht32f175x_275x_i2c.c ht32f175x_275x_lib.c ht32f175x_275x_mctm.c ht32f175x_275x_pdma.c ht32f175x_275x_misc.c ht32f175x_275x_pwrcu.c ht32f175x_275x_rstcu.c ht32f175x_275x_rtc.c ht32f175x_275x_sci.c ht32f175x_275x_serial.c ht32f175x_275x_spi.c ht32f175x_275x_usart.c ht32f175x_275x_usbd.c ht32f175x_275x_wdt.c ht32f275x_csif.c
  group Retarget
    ../library/HT32F175x_275x_Driver/src/: holtek_retarget.c
  group CMSIS
    ./: system_ht32f175x_275x.c
  group Utilities
    ../utilities/HT32F1755_2755_DVB/: ht32f1755_2755_dvb.c i2c_eeprom.c spi_flash.c spi_lcd.c
  group SYSTEM
    ../system/sys/: sys.c
    ../system/delay/: delay.c
    ../system/usart/: usart.c
  group HARDWARE
    ../hardware/KEY/: key.c
    ../hardware/LED/: led.c
    ../hardware/TIMER/: timer.c
    ../hardware/LCD/: lcd.c
    ../hardware/IIC/: myiic.c
    ../hardware/24CXX/: 24cxx.c
    ../hardware/TOUCH/: touch.c
    ../hardware/24bitAD/: 24bitAD.c
    ../hardware/TN9/: TN9.c
    ../hardware/Disp/: disp.c
    ../hardware/RTC/: rtc.c
    ../hardware/FAN/: fan.c
    ../hardware/BUZZER/: buzzer.c
    ../hardware/EX/: chinese.c
